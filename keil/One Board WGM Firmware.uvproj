# Keil uVision project One Board WGM Firmware.uvproj, settings and files
target One Board WGM Firmware (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: One Board WGM Firmware +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP\INC;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32_CPAL_Driver\inc;..\STM32_CPAL_Driver\src;..\STM32_CPAL_Driver\devices\stm32f10x;..\STM32_USB-FS-Device_Driver\inc;..\USB\inc;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\TFT;..\CM3;..\GUIinc;..\uCGUIConfig;..\Startup;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group App/source
    ../APP/SOURCE/: app.c Data_Poll.c GPIO.c WatchDog.c ADC.c stm32f10x_it.c Fun.c DAC.c
    ../STM32_CPAL_Driver/src/: cpal_usercallback.c
  group App/inc
    ../APP/SOURCE/: Flash.c
    ../APP/INC/: Includes.h stm32f10x_conf.h Data_Poll.h GPIO.h ADC.h WatchDog.h Flash.h app_cfg.h os_cfg.h Fun.h DAC.h
  group BSP
    ../BSP/: bsp.c
  group StdPeriph_Driver/souce
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StdPeriph_Driver/inc
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32_CPAL_Driver
    ../STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group STM32_USB-FS-Device_Driver/source
    ../STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_mem.c usb_int.c usb_init.c usb_core.c
  group STM32_USB-FS-Device_Driver/inc
    ../STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group USB/source
    ../USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB/inc
    ../USB/inc/: hw_config.h platform_config.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCGUILib
    ../uCGUILib/: uCGUI_DEMO.lib
  group uCOS-II/GUI_X
    ../uCOS-IIGUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group TFT
    ../TFT/: fsmc_sram.c ili9320.c ili9320_api.c ili9320_ucgui.c lcd_dis24.c
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group GUI_GRAPH
    ../GUI_GRAPH/: GRAPH.c GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_SCALE.c GUI_DrawGraphEx.c GRAPH.h GRAPH_Private.h GUI_DrawGraphEx.h
